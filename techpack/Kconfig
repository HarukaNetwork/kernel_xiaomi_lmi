## techpack/Kconfig
```kconfig
source "techpack/data-kernel/perf/Kconfig"
source "techpack/data-kernel/shs/Kconfig"

source "techpack/audio/Kconfig"
```
